# Keil uVision project PiCncStm32.uvproj, settings and files
target Proj (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PiCncStm32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,  STM32F10X_MD
  c misc: --c99
  c include: ..\libraries\cmsis\cm3\CoreSupport;..\libraries\cmsis\cm3\devicesupport\st\stm32f10x;.\Src;..\libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: startup_stm32f10x_md.s
  group CMSIS
    ../libraries/cmsis/cm3/CoreSupport/: core_cm3.c
    ../libraries/cmsis/cm3/devicesupport/st/stm32f10x/: system_stm32f10x.c
  group Src
    ./Src/: main.c stm32f10x_conf.h
  group StdPeriph
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rcc.c
